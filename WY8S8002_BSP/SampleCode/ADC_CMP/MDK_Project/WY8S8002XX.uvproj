# Keil uVision project WY8S8002XX.uvproj, settings and files
target Project (MCS-51)
  device: WY8S8002XX Wayon
  cpu: IRAM(0 - 0xFF) XRAM(0-0xFFFF) IROM(0-0xFFFF) CLOCK(12000000) MOD517DP
  output: WY8S8002XX +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\Library\inc
  link misc: REMOVEUNUSED
  group Library\Startup
    ../../../Library/Startup/: STARTUP_WY8S8002xx.A51
  group Library\src
    ../../../Library/src/: gpio.c adc.c pwm.c ir.c timer.c uart.c
  group Common
    ../../../Common/: common.c
    ../../../common/: delay.c
  group Source_Code
    ../Source_Code/: main.c board_config.c adc_sample.c soft_uart_rx.c app_logic.c tm1622.c
